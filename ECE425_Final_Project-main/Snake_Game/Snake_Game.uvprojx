# Keil uVision project Snake_Game.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Snake_Game
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group src
    ./: GPIO.c SysTick_Delay.c UART0.c Game_Display.c Game_Logic.c Game_Replay.c
  group inc
    ./: GPIO.h SysTick_Delay.h UART0.h Game_Display.h Game_Logic.h Game_Replay.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
